#
# Recipe for system updater program
#
SRCREV = "${AUTOREV}"

require systemupdater.inc
