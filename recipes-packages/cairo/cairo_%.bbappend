PACKAGECONFIG += "x11 xcb"
TARGET_CFLAGS += "-lX11"

