# Place-holder for now
DEPENDS += " pkgconfig-native"
